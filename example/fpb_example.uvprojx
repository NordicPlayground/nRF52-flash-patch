# Keil uVision project fpb_example.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.5.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: fpb_example
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: NRF52
  c include: ..\lib
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT5: ROM 0x7f000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: main.c flash_patch.c
    ../lib/: fpb_lib.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.5.0
